<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>20000000</value></param>
</block>
<block>
<key>gr_short_to_float</key>
<param><key>id</key><value>gr_short_to_float_0</value></param>
</block>
<block>
<key>gr_short_to_float</key>
<param><key>id</key><value>gr_short_to_float_1</value></param>
</block>
<block>
<key>gr_deinterleave</key>
<param><key>id</key><value>gr_deinterleave_0</value></param>
<param><key>type</key><value>short</value></param>
<param><key>num_streams</key><value>2</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_keep_one_in_n</key>
<param><key>id</key><value>gr_keep_one_in_n_1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>n</key><value>114</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>samp_rate</key><value>44100</value></param>
<param><key>device_name</key><value>plughw:0,0</value></param>
</block>
<block>
<key>gr_complex_to_float</key>
<param><key>id</key><value>gr_complex_to_float_0</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_keep_one_in_n</key>
<param><key>id</key><value>gr_keep_one_in_n_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>n</key><value>114</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_multiply_const_vxx</key>
<param><key>id</key><value>gr_multiply_const_vxx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>0.05</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_sig_source_x</key>
<param><key>id</key><value>gr_sig_source_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate/4</value></param>
<param><key>waveform</key><value>gr.GR_COS_WAVE</value></param>
<param><key>freq</key><value>7e5</value></param>
<param><key>amp</key><value>0.5</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>gr_throttle</key>
<param><key>id</key><value>gr_throttle_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samples_per_second</key><value>5e6</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_wavfile_sink</key>
<param><key>id</key><value>gr_wavfile_sink_0</value></param>
<param><key>file</key><value>/home/phil/SDR_JOVE/gui/remove.wav</value></param>
<param><key>nchan</key><value>1</value></param>
<param><key>samp_rate</key><value>44100</value></param>
<param><key>bits_per_sample</key><value>16</value></param>
</block>
<block>
<key>gr_float_to_complex</key>
<param><key>id</key><value>gr_float_to_complex_0</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_file_source</key>
<param><key>id</key><value>gr_file_source_0</value></param>
<param><key>file</key><value>/home/phil/SDR_JOVE/gui/removeme.dat</value></param>
<param><key>type</key><value>short</value></param>
<param><key>repeat</key><value>False</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_throttle</key>
<param><key>id</key><value>gr_throttle_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samples_per_second</key><value>samp_rate/4</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_multiply_const_vxx</key>
<param><key>id</key><value>gr_multiply_const_vxx_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>const</key><value>0.0014125375456228</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_1</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate/4</value></param>
<param><key>cutoff_freq</key><value>1000000</value></param>
<param><key>width</key><value>100000</value></param>
<param><key>win</key><value>firdes.WIN_RECTANGULAR</value></param>
</block>
<block>
<key>gr_multiply_xx</key>
<param><key>id</key><value>gr_multiply_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>gain</key><value>0.0025</value></param>
<param><key>samp_rate</key><value>samp_rate/4</value></param>
<param><key>cutoff_freq</key><value>25e3</value></param>
<param><key>width</key><value>250000</value></param>
<param><key>win</key><value>firdes.WIN_RECTANGULAR</value></param>
</block>
<block>
<key>wxgui_waterfallsink2</key>
<param><key>id</key><value>wxgui_waterfallsink2_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>Waterfall Plot</value></param>
<param><key>samp_rate</key><value>samp_rate/4</value></param>
<param><key>baseband_freq</key><value>19.5e6</value></param>
<param><key>dynamic_range</key><value>100</value></param>
<param><key>ref_level</key><value>50</value></param>
<param><key>ref_scale</key><value>2</value></param>
<param><key>fft_size</key><value>512</value></param>
<param><key>fft_rate</key><value>30</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0.90</value></param>
<param><key>win</key><value>window.rectangular</value></param>
<param><key>win_size</key><value>(600,500)</value></param>
</block>
<connection><source_block_id>gr_short_to_float_0</source_block_id><sink_block_id>gr_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_short_to_float_1</source_block_id><sink_block_id>gr_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>gr_deinterleave_0</source_block_id><sink_block_id>gr_short_to_float_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_deinterleave_0</source_block_id><sink_block_id>gr_short_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_file_source_0</source_block_id><sink_block_id>gr_deinterleave_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_multiply_const_vxx_1</source_block_id><sink_block_id>wxgui_waterfallsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_keep_one_in_n_1</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_throttle_0</source_block_id><sink_block_id>gr_multiply_const_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_sig_source_x_0</source_block_id><sink_block_id>gr_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>gr_multiply_xx_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_complex_to_float_0</source_block_id><sink_block_id>gr_throttle_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>gr_complex_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_keep_one_in_n_0</source_block_id><sink_block_id>gr_wavfile_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_throttle_0_0</source_block_id><sink_block_id>gr_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_multiply_const_vxx_0</source_block_id><sink_block_id>gr_keep_one_in_n_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_multiply_const_vxx_0</source_block_id><sink_block_id>gr_keep_one_in_n_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_float_to_complex_0</source_block_id><sink_block_id>low_pass_filter_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_1</source_block_id><sink_block_id>gr_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_1</source_block_id><sink_block_id>gr_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
